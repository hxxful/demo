# Keil uVision project demo.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F427IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER
  c include: ..\..\user\app;..\..\user\libs\fatfs;..\..\sys;..\..\bsp\stm32f4\drv;..\..\bsp\stm32f4\drv\common;..\..\bsp\stm32f4\os\uCOS-III\V3.04.05;..\..\bsp\stm32f4\os\uCOS-III\V3.04.05\ports\ARM-Cortex-M4\RealView;..\..\bsp\stm32f4\libs\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\CMSIS;..\..\bsp\stm32f4\libs\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../../user/app/: main.c app_emmc.c
  group FATFS
    ../../user/libs/fatfs/: diskio.c ff.c
  group SYS
    ../../sys/: sys.c sys_api.c sys_delay.c sys_console.c
  group UCOSIII
    ../../bsp/stm32f4/os/uCOS-III/V3.04.05/: app.c bsp.c cpu_core.c lib_ascii.c lib_math.c lib_mem.c lib_str.c os_app_hooks.c os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../bsp/stm32f4/os/uCOS-III/V3.04.05/ports/ARM-Cortex-M4/RealView/: cpu_c.c os_cpu_c.c cpu_a.asm lib_mem_a.asm os_cpu_a.asm
  group DRV
    ../../bsp/stm32f4/drv/: drv_console.c drv_emmc.c
    ../../bsp/stm32f4/drv/common/: drv_delay.c
  group CMSIS
    ../../bsp/stm32f4/libs/STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/CMSIS/: system_stm32f4xx.c startup_stm32f427_437xx.s
  group FWLIB
    ../../bsp/stm32f4/libs/STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
